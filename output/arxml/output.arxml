<?xml version='1.0' encoding='utf-8'?>
<AUTOSAR>
	<AR-PACKAGES>
		<AR-PACKAGE />
	</AR-PACKAGES>
</AUTOSAR>