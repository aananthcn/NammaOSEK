<?xml version='1.0' encoding='utf-8'?>
<!-- Generated by OSEK Builder tool of FreeOSEK project on 2022-02-06 11:27:41.159176 -->
<AUTOSAR>
	<AR-PACKAGES>
		<AR-PACKAGE>
			<SHORT-NAME>Ecuc</SHORT-NAME>
			<ELEMENTS />
		</AR-PACKAGE>
	</AR-PACKAGES>
</AUTOSAR>